# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\libraries\OffChip\AHRS;.\libraries\OffChip\Gimbal;.\libraries\OffChip\InertialSensor;.\libraries\OffChip\Motor;.\libraries\OnChip\ADC;.\libraries\OnChip\IIC;.\libraries\OnChip\InputCapture;.\libraries\OnChip\PWM;.\libraries\OnChip\SerialPort;.\libraries\OnChip\Timer;.\libraries\ToolBox\Buffer;.\libraries\ToolBox\Math;.\libraries\OffChip\Ultrasonic;.\libraries\OffChip\Remoter;.\libraries\System\Interrupt;.\libraries\System;.\libraries\System\TaskManager;.\libraries\OffChip\Compass;.\libraries\OffChip\Barometer;.\libraries\OffChip;.\libraries\ToolBox\Control;.\libraries\OffChip\LED;.\libraries\ToolBox\GidLink;.\libraries\Application;.\libraries\OffChip\ESCMotor;.\libraries\Application\AttitudeControl;.\libraries\Application\Servo;.\libraries\Application\VelocityLoop;.\libraries\Application\PositionLoop;.\libraries\OffChip\GPS;.\RTE\Device;.\RTE\Device\STM32F103C8;.\RTE;.\libraries\OffChip\SHARP_1051_PM2_5;.\libraries\OffChip\esp8266;.\libraries\OnChip\SoftwareI2C;.\libraries\OffChip\DHT12;.\libraries\OnChip\SPI;.\libraries\OffChip\MicroSD;.\libraries\OffChip\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group OnChip
    ./libraries/OnChip/ADC/: ADC.cpp
    ./libraries/OnChip/PWM/: PWM.cpp
    ./libraries/OnChip/SerialPort/: USART.cpp
    ./libraries/OnChip/Timer/: Timer.cpp
    ./libraries/OnChip/InputCapture/: InputCapture_TIM.cpp InputCapture_EXIT.cpp
    ./libraries/OnChip/SoftwareI2C/: SoftwareI2C.cpp
  group OffChip
    ./libraries/OffChip/Remoter/: Remoter_PWM_TIM.cpp Remoter_PWM_EXIT.cpp
    ./libraries/OffChip/LED/: LED.cpp
    ./libraries/OffChip/SHARP_1051_PM2_5/: SHARP_PM2_5.cpp
    ./libraries/OffChip/esp8266/: esp8266.cpp Socket_esp8266.cpp
    ./libraries/OffChip/DHT12/: DHT12.cpp
  group ToolBox
    ./libraries/ToolBox/GidLink/: GidLink.cpp
  group App
    ./: main.cpp
  group System
    ./libraries/System/TaskManager/: TaskManager.cpp
    ./libraries/System/: Configuration.h
    ./libraries/System/Interrupt/: Interrupt.cpp
  group ::Device
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 5.0.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
